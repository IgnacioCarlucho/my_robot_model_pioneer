Commit message: added portability

File: model/pioneer3at_v3.urdf.xacro (robot description, xacro)
@@ -142,5 +142,5 @@
 	      <geometry>
 	        <mesh filename="package://rrbot_description/meshes/hokuyo.dae"/>
-	      </geometry>
+	       </geometry>
 	    </visual>
 	    <inertial>
